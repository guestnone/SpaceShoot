# IAR project SShootMain.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.newCCIncludePaths: ..\..\Source
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group EW2Lib
    ../../Source/EasyWeb2Utility/: CommonRand.c CommonRand.h CommonUtil.c CommonUtil.h EW2.h EW2Buttons.c EW2Buttons.h EW2Buzzer.c EW2Buzzer.h EW2Diodes.c EW2Diodes.h EW2Lcd.c EW2Lcd.h EW2Uart.c EW2Uart.h
  group Main
    ../../Source/Main/: SShootMain.c
